.subckt TOP VDD VSS
.ends
.end
